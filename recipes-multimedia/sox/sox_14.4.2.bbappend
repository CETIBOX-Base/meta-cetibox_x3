PACKAGECONFIG[alsa] = "--with-alsa=dyn,--with-alsa=no,alsa-lib libtool,"
