# Don't use $MACHINE in conf file paths
VSPFILTER_CONF_r8a7795 = "gstvspfilter-h3ulcb_r8a7795.conf"
VSPFILTER_CONF_r8a7796 = "gstvspfilter-m3ulcb_r8a7796.conf"
