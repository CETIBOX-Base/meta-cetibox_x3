FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://devmem2-fix-64bit.patch;striplevel=0 "

