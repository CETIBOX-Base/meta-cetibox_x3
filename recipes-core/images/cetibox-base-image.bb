require cetibox-base-image.inc

DESCRIPTION = "The CETiBOX Base Edition image"

IMAGE_FEATURES += "empty-root-password"
