require cetibox-base-image.inc
require cetibox-base-image-dev.inc

DESCRIPTION = "Image for development work on CETiBOXes"
