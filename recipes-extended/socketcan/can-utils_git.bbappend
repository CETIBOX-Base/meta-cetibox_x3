# Use new version from local git
SRC_URI = "git://github.com/CETIBOX-Base/can-utils.git;protocol=https;branch=master"
SRCREV = "a7223a0920c75348a0563a462855b6d78ae01f33"
