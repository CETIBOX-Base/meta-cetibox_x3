COMPATIBLE_MACHINE =. "|cetibox-m3ulcb"
