COMPATIBLE_MACHINE = "cetibox-m3ulcb|cetibox-h3ulcb"
