LIC_FILES_CHKSUM_append = " \
	file://run-postinsts;beginline=3;endline=5;md5=1ecfa37ddeb87a3f48bd5808a24c9fc3 \
"
